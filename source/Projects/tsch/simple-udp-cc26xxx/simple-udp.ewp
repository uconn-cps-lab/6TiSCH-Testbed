# IAR project simple-udp.ewp, settings and files
configuration root-srf (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: IS_ROOT=1; IS_INTERMEDIATE=0; WITH_UIP6=1; UIP_CONF_TCP=0; xFEATURE_MAC_SECURITY; xTSCH_MAC_USE_MAC64; CC26XX_DEVICES=1; PHY_IEEE_MODE=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f configPkg/compiler.opt.defs
  ICCARM.PreInclude: stdint.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Components/hal; ../../../Components/hal/smartrf06_cc2650; ../../../Components/apps; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$-$CONFIG_NAME$.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$-$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1; USE_SYSBIOS_IN_ROM=1
  ILINK.IlinkIcfFile: simple_udp_cc26xx.icf
  ILINK.IlinkExtraOptions: -f configPkg/linker.cmd; --keep __vector_table
  ILINK.IlinkAdditionalLibs: $PROJ_PATH$/../../lib/tsch-root-cc26xx.a; $DRIVERLIB$/driverlib/bin/iar/driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration int-sensortag (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SENSORTAG=1; IS_ROOT=0; IS_INTERMEDIATE=1; WITH_UIP6=1; UIP_CONF_TCP=0; xFEATURE_MAC_SECURITY; xTSCH_MAC_USE_MAC64; CC26XX_DEVICES=1; PHY_IEEE_MODE=1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Components/hal; ../../../Components/hal/sensortag_cc2650; ../../../Components/sensor; ../../../Components/apps; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
  ILINK.IlinkAdditionalLibs: $PROJ_PATH$/../../lib/tsch-int-cc26xx.a; $DRIVERLIB$/driverlib/bin/iar/driverlib.lib
configuration int-launchpad (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IS_ROOT=0; IS_INTERMEDIATE=1; WITH_UIP6=1; UIP_CONF_TCP=0; xFEATURE_MAC_SECURITY; xTSCH_MAC_USE_MAC64; CC26XX_DEVICES=1; PHY_IEEE_MODE=1
  ILINK.IlinkAdditionalLibs: as above
configuration root-launchpad (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IS_ROOT=1; WITH_UIP6=1; UIP_CONF_TCP=0; xFEATURE_MAC_SECURITY; xTSCH_MAC_USE_MAC64; CC26XX_DEVICES=1; PHY_IEEE_MODE=1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Components/hal; ../../../Components/hal/launchpad_cc2650; ../../../Components/apps; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
configuration root-i3 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IS_ROOT=1; WITH_UIP6=1; UIP_CONF_TCP=0; xFEATURE_MAC_SECURITY; CC26XX_DEVICES=1; PHY_IEEE_MODE=1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Components/hal; ../../../Components/hal/i3mote_cc2650; ../../../Components/sensor; ../../../Components/apps; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
configuration int-i3 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: I3_MOTE=1; IS_ROOT=0; IS_INTERMEDIATE=1; WITH_UIP6=1; UIP_CONF_TCP=0; xFEATURE_MAC_SECURITY; xTSCH_MAC_USE_MAC64; CC26XX_DEVICES=1; PHY_IEEE_MODE=1
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkAdditionalLibs: as above
configuration int-srf (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ILINK.IlinkAdditionalLibs: as above
  group APP/pwrest
    ../../../Components/apps/pwrest/: pwrest.c pwrest.h
  group APP/simple-udp
    ../../../Components/apps/simple-udp/: simple-udp-leaf.c simple-udp-root.c simple-udp-sensors.c simple-udp-sensors.h
  group CONFIG
    ../../../Components/hal/: ccfg.c
    ../../../Components/uip/inc/: config-rpl-public.h config-uip-public.h
    ../../../Components/tsch/: mac_config.c mac_config.h
    ./: simple_udp_cc26xx.cfg simple_udp_cc26xx.icf
  group HAL
    ../../../Components/hal/: hal_api.h hal_main.c led.h rf_cc26xx.c rf_cc26xx.h rtimer-arch.c rtimer-arch.h
  group HAL/i3mote
    ../../../Components/hal/i3mote_cc2650/: Board.c Board.h led.c
  group HAL/inc
    ../../../Components/hal/inc/: ieee_cmd.h RF.h RFCC26XX_singleMode.c
  group HAL/launchpad
    ../../../Components/hal/launchpad_cc2650/: Board.c Board.h led.c
  group HAL/sensortag
    ../../../Components/hal/sensortag_cc2650/: Board.c Board.h led.c
  group HAL/smartrf06
    ../../../Components/hal/smartrf06_cc2650/: Board.c Board.h led.c
  group STACK/sensor
    ../../../Components/sensor/: SensorBatMon.c SensorBatMon.h SensorBmp280.c SensorBmp280.h SensorHDC1000.c SensorHDC1000.h SensorI2C.c SensorI2C.h SensorLIS2HH12.c SensorLIS2HH12.h SensorMpu9250.c SensorMpu9250.h SensorOpt3001.c SensorOpt3001.h SensorTmp007.c SensorTmp007.h SensorUtil.c SensorUtil.h
  group STACK/TSCH
    ../../../Components/tsch/: nhl_api.c nhl_api.h nhl_setup.c nhl_setup.h
  group STACK/uIP/conf
    ../../../Components/uip/conf/: plat-conf.h rpl-conf.h uip-conf.h
  group STACK/uIP/inc
    ../../../Components/uip/inc/: config-rpl-private.h config-uip-private.h
  group STACK/uIP/lib
    ../../../Components/uip/lib/: list.c list.h memb.c memb.h random.c random.h
  group STACK/uIP/net
    ../../../Components/uip/net/: nbr-table.c nbr-table.h packetbuf.c packetbuf.h queuebuf.c queuebuf.h sicslowpan.c sicslowpan.h tcpip.c tcpip.h udp-simple-socket.c udp-simple-socket.h uip-debug.c uip-debug.h uip-ds6-nbr.c uip-ds6-nbr.h uip-ds6-route.c uip-ds6-route.h uip-ds6.c uip-ds6.h uip-fw.c uip-fw.h uip-icmp6.c uip-icmp6.h uip-nd6.c uip-nd6.h uip-packetqueue.c uip-packetqueue.h uip-split.c uip-split.h uip-udp-packet.c uip-udp-packet.h uip.h uip6.c uip_arch.h uipopt.h
  group STACK/uIP/pltfrm
    ../../../Components/uip/pltfrm/sysbios/: pltfrm_lib.c pltfrm_lib.h
  group STACK/uIP/rime
    ../../../Components/uip/rime/: rimeaddr.c rimeaddr.h
  group STACK/uIP/rpl
    ../../../Components/uip/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-plusplus.c rpl-plusplus.h rpl-private.h rpl-routing-header.c rpl-routing-header.h rpl-timers.c rpl.c rpl.h rpl_api.h rpl_ipv6_api.h
  group STACK/uIP/sys
    ../../../Components/uip/sys/: clock.c clock.h ctimer.c ctimer.h etimer.c etimer.h process.h stimer.c stimer.h timer.c timer.h
  group STACK/uIP/uip_rpl_impl
    ../../../Components/uip/uip_rpl_impl/: uip_rpl_attributes.c uip_rpl_attributes.h
    ../../../Components/uip/uip_rpl_impl/sysbios/: uip_rpl_process.c uip_rpl_process.h
