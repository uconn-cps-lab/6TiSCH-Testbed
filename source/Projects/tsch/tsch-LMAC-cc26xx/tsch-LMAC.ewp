# IAR project tsch-LMAC.ewp, settings and files
configuration root-sensortag (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: IS_ROOT=1; IS_INTERMEDIATE=0; WITH_UIP6=0; xTSCH_MAC_USE_MAC64; ENABLE_HCT=1; CC26XX_DEVICES=1; PHY_IEEE_MODE=1; FEATURE_MAC_SECURITY=1; GW_SCHED=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f configPkg/compiler.opt.defs
  ICCARM.PreInclude: stdint.h
  ICCARM.CCIncludePath2: PROJ_DIR$; ../../../Components/inc; ../../../Components/hal; ../../../Components/hal/sensortag_cc2650; ../../../Components/apps; ../../../Components/apps/HCT; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$-$CONFIG_NAME$.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$-$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1; USE_SYSBIOS_IN_ROM=1
  ILINK.IlinkIcfFile: tsch_LMAC_cc26xx.icf
  ILINK.IlinkExtraOptions: -f configPkg/linker.cmd; --keep __vector_table
  ILINK.IlinkAdditionalLibs: $DRIVERLIB$/driverlib/bin/iar/driverlib.lib; $PROJ_PATH$/../../lib/tsch-root-mac-only-cc26xx.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration root-i3 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IS_ROOT=1; IS_INTERMEDIATE=0; WITH_UIP6=0; xTSCH_MAC_USE_MAC64; ENABLE_HCT=1; CC26XX_DEVICES=1; PHY_IEEE_MODE=1; FEATURE_MAC_SECURITY=1; GW_SCHED=1; DTLS_LEDS_ON=1
  ICCARM.CCIncludePath2: PROJ_DIR$; ../../../Components/hal; ../../../Components/hal/i3mote_cc2650; ../../../Components/apps; ../../../Components/apps/HCT; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
  group APP
    ../../../Components/apps/tsch-only/: tsch_root.c
  group APP/pwrest
    ../../../Components/apps/pwrest/: pwrest.c pwrest.h
  group CONFIG
    ../../../Components/hal/: ccfg.c
    ../../../Components/inc/: config-sn.h
    ../../../Components/tsch/: mac_config.c mac_config.h nv_params.c
    ../../../Components/uip/inc/: nv_params.h
    ./: tsch_LMAC_cc26xx.cfg tsch_LMAC_cc26xx.icf
  group HAL
    ../../../Components/hal/: CryptoCC26XX.c CryptoCC26XX.h hal_api.h hal_main.c led.h NVS.c NVS.h NVSCC26XX.c NVSCC26XX.h rf_cc26xx.c rf_cc26xx.h rtimer-arch.c rtimer-arch.h UARTCC26XX.c UARTCC26XX.h
  group HAL/i3mote
    ../../../Components/hal/i3mote_cc2650/: Board.c Board.h led.c
  group HAL/inc
    ../../../Components/hal/inc/: ieee_cmd.h RF.h RFCC26XX_singleMode.c
  group HAL/sensortag
    ../../../Components/hal/sensortag_cc2650/: Board.c Board.h led.c
  group HCT
    ../../../Components/apps/HCT/: crc16.c crc16.h hct.h hct_load_system_config.c hct_msg_data.c hct_rx.c hct_tx.c hct_tx_task.c tlv.c tlv.h
  group STACK/tsch
    ../../../Components/tsch/: nhl_api.c nhl_api.h nhl_setup.c nhl_setup.h
  group STACK/uIP/lib
    ../../../Components/uip/lib/: list.c list.h memb.c memb.h random.c random.h
  group STACK/uIP/net
    ../../../Components/uip/net/: packetbuf.c packetbuf.h
  group STACK/uIP/sys
    ../../../Components/uip/sys/: clock.c clock.h
