# IAR project tsch-LMAC-13xx.ewp, settings and files
configuration root-launchpad (ARM, debug)
  General.OGChipSelectEditMenu: CC1350F128 TexasInstruments CC1350F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CC1310F128; RFC_INCLUDE_GFSK; IS_ROOT=1; IS_INTERMEDIATE=0; WITH_UIP6=0; WITH_ULPSMAC=1; UIP_SMARTNET; FEATURE_MAC_SECURITY=1; xTSCH_MAC_USE_MAC64; ENABLE_HCT; CC13XX_DEVICES=1; PHY_PROP_50KBPS=1; GW_SCHED=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f configPkg/compiler.opt.defs
  ICCARM.PreInclude: stdint.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Components/hal; ../../../Components/hal/launchpad_cc1310; ../../../Components/apps; ../../../Components/apps/HCT; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$-$CONFIG_NAME$.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$-$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1; USE_SYSBIOS_IN_ROM=1
  ILINK.IlinkIcfFile: tsch_LMAC_cc13XX.icf
  ILINK.IlinkExtraOptions: -f configPkg/linker.cmd; --keep __vector_table
  ILINK.IlinkAdditionalLibs: $DRIVERLIB$/driverlib/bin/iar/driverlib.lib; $PROJ_PATH$/../../lib/tsch-root-mac-only-cc13xx.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration root-i3 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Components/hal; ../../../Components/hal/i3mote_cc1350; ../../../Components/apps; ../../../Components/apps/HCT; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
  group APP
    ../../../Components/apps/tsch-only/: tsch_root.c
  group APP/pwrest
    ../../../Components/apps/pwrest/: pwrest.c pwrest.h
  group CONFIG
    ../../../Components/hal/: ccfg.c NVS.c NVS.h NVSCC26XX.c NVSCC26XX.h
    ../../../Components/tsch/: mac_config.c mac_config.h
    ./: tsch_LMAC_cc13xx.cfg tsch_LMAC_cc13xx.icf
  group HAL
    ../../../Components/hal/: CryptoCC26XX.c CryptoCC26XX.h hal_api.h hal_main.c led.h rf_cc13xx.c rf_cc13xx.h rtimer-arch.c rtimer-arch.h UARTCC26XX.c UARTCC26XX.h
    ../../../Components/tsch/: nv_params.c
    ../../../Components/uip/inc/: nv_params.h
  group HAL/i3
    ../../../Components/hal/i3mote_cc1350/: Board.c Board.h led.c
  group HAL/launchpad
    ../../../Components/hal/launchpad_cc1310/: Board.c Board.h led.c
  group HCT
    ../../../Components/apps/HCT/: crc16.c crc16.h hct.h hct_load_system_config.c hct_msg_data.c hct_rx.c hct_tx.c hct_tx_task.c tlv.c tlv.h
  group STACK/tsch
    ../../../Components/tsch/: nhl_api.c nhl_api.h nhl_setup.c nhl_setup.h
  group STACK/uIP/lib
    ../../../Components/uip/lib/: list.c list.h memb.c memb.h random.c random.h
  group STACK/uIP/net
    ../../../Components/uip/net/: packetbuf.c packetbuf.h
  group STACK/uIP/sys
    ../../../Components/uip/sys/: clock.c clock.h
