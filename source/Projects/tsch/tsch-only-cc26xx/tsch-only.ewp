# IAR project tsch-only.ewp, settings and files
configuration leaf-sensortag (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: SENSORTAG=1; IS_ROOT=0; IS_INTERMEDIATE=0; WITH_UIP6=0; CC26XX_DEVICES=1; PHY_IEEE_MODE=1; xFEATURE_MAC_SECURITY; xTSCH_MAC_USE_MAC64
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f configPkg/compiler.opt.defs
  ICCARM.PreInclude: stdint.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Components/hal; ../../../Components/hal/sensortag_cc2650; ../../../Components/sensor; ../../../Components/apps; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; ../../../Components/tsch/_common; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$-$CONFIG_NAME$.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$-$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1; USE_SYSBIOS_IN_ROM=1
  ILINK.IlinkIcfFile: tsch_only_cc26xx.icf
  ILINK.IlinkExtraOptions: -f configPkg/linker.cmd; --keep __vector_table
  ILINK.IlinkAdditionalLibs: $DRIVERLIB$/driverlib/bin/iar/driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration leaf-i3 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: I3_MOTE=1; IS_ROOT=0; IS_INTERMEDIATE=0; WITH_UIP6=0; CC26XX_DEVICES=1; PHY_IEEE_MODE=1; xFEATURE_MAC_SECURITY; xTSCH_MAC_USE_MAC64
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Components/inc; ../../../Components/hal; ../../../Components/hal/i3mote_cc2650; ../../../Components/sensor; ../../../Components/apps; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; ../../../Components/tsch/_common; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
configuration leaf-srf06 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IS_ROOT=0; IS_INTERMEDIATE=1; WITH_UIP6=0; CC26XX_DEVICES=1; PHY_IEEE_MODE=1; xFEATURE_MAC_SECURITY; xTSCH_MAC_USE_MAC64
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Components/inc; ../../../Components/hal; ../../../Components/hal/smartrf06_cc2650; ../../../Components/apps; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; ../../../Components/tsch/_common; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
configuration root-i3 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IS_ROOT=1; IS_INTERMEDIATE=0; WITH_UIP6=0; CC26XX_DEVICES=1; PHY_IEEE_MODE=1; xFEATURE_MAC_SECURITY; xTSCH_MAC_USE_MAC64
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Components/inc; ../../../Components/hal; ../../../Components/hal/sensortag_cc2650; ../../../Components/apps; ../../../Components/sensor; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
configuration root-srf06 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
configuration root-sensortag (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  group APP
    ../../../Components/uip/net/: packetbuf.c packetbuf.h
    ../../../Components/apps/tsch-only/: tsch_leaf.c tsch_root.c
  group APP/pwrest
    ../../../Components/apps/pwrest/: pwrest.c pwrest.h
  group APP/simple-udp
    ../../../Components/apps/simple-udp/: simple-udp-sensors.c simple-udp-sensors.h
  group CONFIG
    ../../../Components/hal/: ccfg.c
    ../../../Components/tsch/: mac_config.c mac_config.h
    ./: tsch_only_cc26xx.cfg tsch_only_cc26xx.icf
  group HAL
    ../../../Components/hal/: hal_api.h hal_main.c led.h rf_cc26xx.c rf_cc26xx.h rtimer-arch.c rtimer-arch.h
  group HAL/i3mote
    ../../../Components/hal/i3mote_cc2650/: Board.c Board.h led.c
  group HAL/inc
    ../../../Components/hal/inc/: ieee_cmd.h RF.h RFCC26XX_singleMode.c
  group HAL/sensortag
    ../../../Components/hal/sensortag_cc2650/: Board.c Board.h led.c
  group HAL/smartrf06
    ../../../Components/hal/smartrf06_cc2650/: Board.c Board.h led.c
  group STACK/sensor
    ../../../Components/sensor/: SensorBatMon.c SensorBatMon.h SensorBmp280.c SensorBmp280.h SensorHDC1000.c SensorHDC1000.h SensorI2C.c SensorI2C.h SensorLIS2HH12.c SensorLIS2HH12.h SensorMpu9250.c SensorMpu9250.h SensorOpt3001.c SensorOpt3001.h SensorTmp007.c SensorTmp007.h SensorUtil.c SensorUtil.h
  group STACK/tsch
    ../../../Components/tsch/: bm_api.c bm_api.h bsp_aes.c bsp_aes.h frame802154e.c frame802154e.h framer-802154e.c framer-802154e.h framer.h ie802154e.c ie802154e.h lowmac-tsch.c lowmac-tsch.h lowmac.h mac.h mac_pib.c mac_pib.h mac_pib_pvt.h mac_reset.c mac_reset.h mrxm.c mrxm.h mtxm.c mtxm.h nhl.h nhl_api.c nhl_api.h nhl_device_table.c nhl_device_table.h nhl_mgmt.c nhl_mgmt.h nhl_mlme_cb.c nhl_mlme_cb.h nhl_setup.c nhl_setup.h nhl_task.c nhldb-tsch-cmm.c nhldb-tsch-cmm.h nhldb-tsch-nonpc.c nhldb-tsch-nonpc.h nhldb-tsch-pc.c nhldb-tsch-pc.h nhldb-tsch-sched.c nhldb-tsch-sched.h pib-802154e.h pnm-db.c pnm-db.h pnm.c pnm.h prmtv802154e.c prmtv802154e.h rtimer.c rtimer.h stat802154e.h tsch-acm.c tsch-acm.h tsch-db.c tsch-db.h tsch-pib.h tsch-rxm.c tsch-rxm.h tsch-txm.c tsch-txm.h tsch_api.h tsch_os_fun.c tsch_os_fun.h ulpsmac.c ulpsmac.h ulpsmacaddr.c ulpsmacaddr.h ulpsmacbuf.h upmac-802154e.c upmac-802154e.h upmac.h
  group STACK/uip/lib
    ../../../Components/uip/lib/: list.c list.h memb.c memb.h random.c random.h
  group STACK/uip/sys
    ../../../Components/uip/sys/: clock.c clock.h
