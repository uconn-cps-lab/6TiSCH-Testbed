# IAR project lib-gen.ewp, settings and files
configuration root-mac-only-cc26xx (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: IS_ROOT=1; IS_INTERMEDIATE=0; WITH_UIP6=0; WITH_ULPSMAC=1; CC26XX_DEVICES=1; PHY_IEEE_MODE=1; xTSCH_MAC_USE_MAC64; ENABLE_HCT=1; GW_SCHED; FEATURE_MAC_SECURITY=1; DTLS_LEDS_ON=1; REDUCE_TIMESLOT_LENGTH=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f configPkg/compiler.opt.defs
  ICCARM.PreInclude: stdint.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Components/inc; ../../../Components/hal; ../../../Components/hal/smartrf06_cc2650; ../../../Components/apps; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tsch-lib.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: tsch-only-root.out
  ILINK.IlinkConfigDefines: CC2650=1; FLASH_ONLY_BUILD=1; xUSE_SYSBIOS_IN_ROM=1
  ILINK.IlinkIcfFile: config\cc26xx.icf
  ILINK.IlinkExtraOptions: -f configPkg/linker.cmd; --keep __vector_table
  ILINK.IlinkAdditionalLibs: $DRIVERLIB$/driverlib/bin/iar/driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration int-cc26xx (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IS_ROOT=0; HARP_MINIMAL=1; IS_INTERMEDIATE=1; WITH_UIP6=1; CC26XX_DEVICES=1; PHY_IEEE_MODE=1; xTSCH_MAC_USE_MAC64; FEATURE_MAC_SECURITY=1; MAX_NUM_OF_OUTSTANDING_PACKETS=1; MAX_NUM_OUTSTANDING_UIP_PACKETS=1; REDUCE_TIMESLOT_LENGTH=1
  ICCARM.CCOptLevel: 3
configuration root-mac-only-cc13xx (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IS_ROOT=1; IS_INTERMEDIATE=0; WITH_UIP6=0; CC13XX_DEVICES=1; PHY_PROP_50KBPS=1; FEATURE_MAC_SECURITY=1; xTSCH_MAC_USE_MAC64; ENABLE_HCT=1; GW_SCHED=1
  ICCARM.CCOptLevel: 3
configuration int-cc13xx (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IS_ROOT=0; IS_INTERMEDIATE=1; WITH_UIP6=1; CC13XX_DEVICES=1; PHY_PROP_50KBPS=1; FEATURE_MAC_SECURITY=1; xTSCH_MAC_USE_MAC64
  ICCARM.CCOptLevel: 3
  group (top)
    ./: lib-gen.cfg
  group STACK/tsch
    ../../../Components/tsch/: bm_api.c bm_api.h bsp_aes.c bsp_aes.h frame802154e.c frame802154e.h framer-802154e.c framer-802154e.h framer.h ie802154e.c ie802154e.h lowmac-tsch.c lowmac-tsch.h lowmac.h mac.h mac_pib.c mac_pib.h mac_pib_pvt.h mac_reset.c mac_reset.h mac_security_api.h mac_tsch_security.c mac_tsch_security.h mrxm.c mrxm.h mtxm.c mtxm.h nhl.h nhl_device_table.c nhl_device_table.h nhl_mgmt.c nhl_mgmt.h nhl_mlme_cb.c nhl_mlme_cb.h nhl_task.c nhldb-tsch-cmm.c nhldb-tsch-cmm.h nhldb-tsch-nonpc.c nhldb-tsch-nonpc.h nhldb-tsch-pc.c nhldb-tsch-pc.h nhldb-tsch-sched.c nhldb-tsch-sched.h pib-802154e.h pnm-db.c pnm-db.h pnm.c pnm.h prmtv802154e.c prmtv802154e.h rtimer.c rtimer.h stat802154e.h tsch-acm.c tsch-acm.h tsch-db.c tsch-db.h tsch-pib.h tsch-rxm.c tsch-rxm.h tsch-txm.c tsch-txm.h tsch_api.h tsch_os_fun.c tsch_os_fun.h ulpsmac.c ulpsmac.h ulpsmacaddr.c ulpsmacaddr.h ulpsmacbuf.h upmac-802154e.c upmac-802154e.h upmac.h
